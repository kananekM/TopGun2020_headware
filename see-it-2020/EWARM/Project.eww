<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\see-it-2020.ewp</path>
  </project>
  <batchBuild />
</workspace>
